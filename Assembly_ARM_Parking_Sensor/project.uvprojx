# Keil uVision project project.uvprojx, settings and files
target Target 1 (6140001::V6.14.1::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: InChar.s OutChar.s OutStr.s Startup.s main.s CONVRT.s DELAY100.s PORTB4_INIT.s MEAS_2.s INIT_TIMER_1A.s INIT_SW.s StepRight.s INIT_TIMER_0A.s PORTC_INIT.s INIT_PORTE3_ADC.s SAVE_SAMPLE.s PORTF_HAND.s PORTA_INIT.s INIT_SSI0.s INIT_SCREEN.s PORTD_INIT.s WRITE_COM.s WRITE_DISP.s FIRST_DISPLAY.s CLEAR_SCREEN.s WRITE_ASCII.s UPDATE_MEAS.s DELAY1.s UPDATE_SAMP.s BRAKES_DISP.s NORMAL_OP.s THRESHOLD_OP.s UPDATE_BAR.s UPDATE_SPEED.s
